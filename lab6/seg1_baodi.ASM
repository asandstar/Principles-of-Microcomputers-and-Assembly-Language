;保底,实现了功能但没完全满足要求
/*1.无键参与，数码管动态扫描(定时器中断延时），静屏（视觉上静止）显示：8个数码管自左至右显示“0-7”*/

;P1接段选通，P0接位选通
	ORG 0000H
	LJMP MAIN

   	ORG 0100H
MAIN:
	MOV 93H,#00H  ;p0推挽模式,位选通
	MOV 94H,#0FFH
	MOV 91H,#00H  ;P1推挽模式，段选通
	MOV 92H,#0FFH
	MOV 95H,#00H  ;P2推挽模式
	MOV 96H,#0FFH
;位码低有效
SEG1:	
	MOV B,#11111110B
	MOV P0,B 
	MOV A,#3FH
	MOV P1,A
	LCALL DELAY1MS
SEG2:	
	MOV B,#11111101B
	MOV P0,B 
	MOV A,#06H
	MOV P1,A
	LCALL DELAY1MS
SEG3:
	MOV B,#11111011B
	MOV P0,B 
	MOV A,#5BH
	MOV P1,A
	LCALL DELAY1MS
SEG4:
	MOV B,#11110111B
	MOV P0,B 
	MOV A,#4FH
	MOV P1,A
	LCALL DELAY1MS
SEG5:
	MOV B,#11101111B
	MOV P0,B 
	MOV A,#66H
	MOV P1,A
	LCALL DELAY1MS
SEG6:
	MOV B,#11011111B
	MOV P0,B 
	MOV A,#6DH
	MOV P1,A
	LCALL DELAY1MS
SEG7:
	MOV B,#10111111B
	MOV P0,B 
	MOV A,#7DH
	MOV P1,A
	LCALL DELAY1MS
SEG8:
	MOV B,#01111111B
	MOV P0,B 
	MOV A,#07H
	MOV P1,A
	LCALL DELAY1MS
	LJMP SEG1	
DELAY1MS:			;@11.0592MHz
	PUSH	30H
	PUSH	31H
	MOV		30H,#9
	MOV		31H,#150
NEXT2:
	DJNZ	31H,NEXT2
	DJNZ	30H,NEXT2
	POP		31H
	POP		30H
	RET
 	END

